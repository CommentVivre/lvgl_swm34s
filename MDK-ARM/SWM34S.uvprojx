# Keil uVision project SWM34S.uvprojx, settings and files
target SWM34S (6230000::V6.23::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.4
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: SWM34S
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: ..\Drivers\CMSIS\CoreSupport;..\Drivers\CMSIS\DeviceSupport;..\Drivers\SWM341_StdPeriph_Driver;..\LVGL;..\LVGL\src;..\LVGL\src\core;..\LVGL\src\draw;..\LVGL\src\draw\arm2d;..\LVGL\src\draw\nxp\pxp;..\LVGL\src\draw\nxp\vglite;..\LVGL\src\draw\sdl;..\LVGL\src\draw\stm32_dma2d;..\LVGL\src\draw\sw;..\LVGL\src\draw\swm341_dma2d;..\LVGL\src\extra;..\LVGL\src\extra\layouts;..\LVGL\src\extra\layouts\flex;..\LVGL\src\extra\layouts\grid;..\LVGL\src\extra\libs;..\LVGL\src\extra\libs\bmp;..\LVGL\src\extra\libs\ffmpeg;..\LVGL\src\extra\libs\freetype;..\LVGL\src\extra\libs\fsdrv;..\LVGL\src\extra\libs\gif;..\LVGL\src\extra\libs\png;..\LVGL\src\extra\libs\qrcode;..\LVGL\src\extra\libs\rlottie;..\LVGL\src\extra\libs\sjpg;..\LVGL\src\extra\others;..\LVGL\src\extra\others\fragment;..\LVGL\src\extra\others\gridnav;..\LVGL\src\extra\others\ime;..\LVGL\src\extra\others\imgfont;..\LVGL\src\extra\others\monkey;..\LVGL\src\extra\others\msg;..\LVGL\src\extra\others\snapshot;..\LVGL\src\extra\themes;..\LVGL\src\extra\themes\basic;..\LVGL\src\extra\themes\default;..\LVGL\src\extra\themes\mono;..\LVGL\src\extra\widgets;..\LVGL\src\extra\widgets\animimg;..\LVGL\src\extra\widgets\calendar;..\LVGL\src\extra\widgets\chart;..\LVGL\src\extra\widgets\colorwheel;..\LVGL\src\extra\widgets\imgbtn;..\LVGL\src\extra\widgets\keyboard;..\LVGL\src\extra\widgets\led;..\LVGL\src\extra\widgets\list;..\LVGL\src\extra\widgets\menu;..\LVGL\src\extra\widgets\meter;..\LVGL\src\extra\widgets\msgbox;..\LVGL\src\extra\widgets\span;..\LVGL\src\extra\widgets\spinbox;..\LVGL\src\extra\widgets\spinner;..\LVGL\src\extra\widgets\tabview;..\LVGL\src\extra\widgets\tileview;..\LVGL\src\extra\widgets\win;..\LVGL\src\font;..\LVGL\src\hal;..\LVGL\src\misc;..\LVGL\src\widgets;..\LVGL\examples\porting;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM33_NTZ\non_secure;..\FreeRTOS\portable\GCC\ARM_CM33\non_secure;..\FreeRTOS\portable\GCC\ARM_CM33\secure;..\FreeRTOS\CMSIS_RTOS_V2;..\FreeRTOS;..\LVGL\demos\widgets;..\LVGL\demos\widgets\assets;..\LVGL\demos\benchmark;..\LVGL\demos\benchmark\assets;..\LVGL\demos\music;..\LVGL\demos\music\assets;..\Core
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\SWM34S.sct
  group Application
    ../Core/: main.c swm341_it.c task.c
  group Drivers
    ../Core/driver/: gt9xx.c key.c lcd_pwm.c lcd_rgb.c led.c sdram.c sfc_w25q64.c timer.c uart.c
  group LVGL_UI
    ../Core/lvgl/: callback.c lv_board_control.c lv_compressor_control.c lv_fan_control.c lv_font_sy_16.c main_windows.c navigation.c lv_color_def.c
  group Drivers/SWM341_StdPeriph_Driver
    ../Drivers/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_can.c SWM341_cordic.c SWM341_crc.c SWM341_dac.c SWM341_div.c SWM341_dma.c SWM341_dma2d.c SWM341_exti.c SWM341_flash.c SWM341_gpio.c SWM341_i2c.c SWM341_iofilt.c SWM341_jpeg.c SWM341_lcd.c SWM341_port.c SWM341_pwm.c SWM341_qei.c SWM341_rtc.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_spi.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_usbh.c SWM341_wdt.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DeviceSupport/: system_SWM341.c
    ../Drivers/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group LVGL
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/src/extra/: lv_extra.c
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/src/extra/others/msg/: lv_msg.c
    ../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/span/: lv_span.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group LVGL_Porting
    ../LVGL/examples/porting/: lv_port_disp.c lv_port_indev.c
    ../LVGL/: lv_conf.h
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ../FreeRTOS/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
